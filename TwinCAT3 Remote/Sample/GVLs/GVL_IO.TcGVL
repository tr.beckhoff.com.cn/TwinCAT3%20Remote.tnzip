{attribute 'qualified_only'}
VAR_GLOBAL
	EL1859_IN	AT %IB1 :ARRAY [1..2,1..8] OF BOOL;
	EL1859_OUT	AT	%QB1	:ARRAY [1..2,1..8] OF BOOL;
	IntTest1 :INT;
END_VAR
